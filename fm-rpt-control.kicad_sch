File: fm-rpt-control.kicad_sch (KiCad schematic)
At the start: 154 parts, among them IC1 74HC107D, IC2 74HC393M, IC3 74HC85D, J1 DUPLEX_RX, J2 SIMPLEX, J3 Conn_01x03_Male, J4 Conn_01x03_Male, J5 Conn_01x03_Male, J6 Conn_01x03_Male, J7 Conn_01x03_Male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

Commit message: before replacing some pinheaders with switches
Parts:
- added SW7: SW_SPDT, swtiches_spdt_dpdt:TL3XWO, symbol Switch:SW_SPDT
- added SW8: SKHHLRA010, Button_Switch_THT:SW_Tactile_SKHH_Angled, symbol Switch:SW_Push
- added SW9: SW_Push_DPDT, swtiches_spdt_dpdt:Ninigi_SS22F03-G6, symbol Switch:SW_Push_DPDT
- added U35: 74AHC1G32GW, Package_TO_SOT_SMD:SOT-353_SC-70-5_Handsoldering, symbol 74xGxx:74AHC1G32
- SW1: footprint sterownik:TL3XWO -> swtiches_spdt_dpdt:Ninigi_MSS-2235S
- SW2, SW3, SW5: footprint sterownik:TL3XWO -> swtiches_spdt_dpdt:TL3XWO
- SW4: footprint sterownik:TL4XWO -> swtiches_spdt_dpdt:TL4XWO
Connections:
- net GND is gone; now on net +5V: ACC1.15 (Pin_15), ACC1.16 (Pin_16), C11.2, C12.2, C13.2, C14.2, C15.2, C6.2, C7.2, C8.2, C9.2, D11.2 (A)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
- net +5V: now also SW7.1 (A), SW7.3 (C), SW8.1, U35.3 (GND), U35.5 (VCC)
- net DPX_LOOP_INH_FROM_ACC: now also U35.4; no longer U19.9 (2Y3)
- net RETRNSMIT_ND_FROM_ACC: now reaches U14.2, U19.12 (1Y3)
- net at C8.1, D15.1 (K), R51.1: now also SW8.2
- net SPX_INHIBIT_CNTRL: now reaches SW3.2 (B), U21.5
- new net: U19.9 (2Y3), U35.2
- new net DPX_LOOP_INH_CNTRL: SW7.2 (B), U35.1
- no-connect marks 29 -> 28
Other:
- note added: "Switch DPDT: TST 2 N-RA KNITTER-SWITCH; Swtich SPDT: TST 1 D-RA KNITTER-SWITCH; 5FS1S102M6QE NINIGI"
- moved on the sheet: U14

Commit message: short
Parts:
- removed J3, J4, J6, J7: Conn_01x03_Male, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector:Conn_01x03_Male
- added SW10: SW_Push_DPDT, swtiches_spdt_dpdt:Ninigi_SS22F03-G6, symbol Switch:SW_Push_DPDT
Connections:
- net +5V: no longer C11.2, C12.2, C13.2, C14.2, C15.2, C9.2
- net DPX_FLAT_PTT: now also SW10.3 (C)
- net DPX_FLAT_TX_AUD: now also SW10.6 (C)
- net DPX_PTT: now also SW10.1 (A)
- net DPX_TX_AUD: now also SW10.4 (A)
- net SPX_FLAT_PTT: now also SW9.6 (C)
- net SPX_FLAT_TX_AUD: now also SW9.3 (C)
- net SPX_PTT: now also SW9.4 (A)
- net SPX_TX_AUD: now also SW9.1 (A)
- net at C3.1: now also SW9.2 (B)
- net at C10.1: now also SW10.5 (B)
- net at R13.1: now also SW9.5 (B)
- net at U30.4: now also SW10.2 (B)
- no-connect marks 28 -> 23
Other:
- moved on the sheet: R13, SW9

Commit message: +5v bus removed completely
Connections:
- net +5V renamed GND
- net GND: no longer C11.1, C12.1, C13.1, C14.1, C15.1, C9.1, F4.2, IC1.14 (VCC), IC2.14 (VCC), IC3.16 (VCC), IC3.3 (A=B_I), Q1.2 (E)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
- new net: C11.1, C12.1, C13.1, C14.1, C15.1, C9.1
- new net: Q2.2 (E), R28.2
- new net: Q3.2 (E), R23.2
- new net: R4.2, R5.2
- new net: IC1.14 (VCC), IC2.14 (VCC), IC3.16 (VCC), U11.14 (VCC)
- new net: U20.14 (VCC), U21.14 (VCC), U22.14 (VCC), U8.14 (VCC)
- new net: Q1.2 (E), R26.2
- new net: U13.14 (VCC), U15.14 (VCC), U16.14 (VCC), U17.14 (VCC), U18.14 (VCC)
- new net: R1.2, R2.2, R3.2
- new net: SW1.2 (B), U15.4 (~{S})
- new net: R44.1, R46.1, R47.1, R50.1

Commit message: test
Connections:
- net GND: now also C11.2, C12.2, C13.2, C14.2, C15.2, C9.2
- net +5V: now reaches U26.8 (VCC)
- net +5V: now also C11.1, C12.1, C13.1, C14.1, C15.1, C9.1, IC1.14 (VCC), IC2.14 (VCC), IC3.16 (VCC), Q2.2 (E), Q3.2 (E), R1.2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

Commit message: short fixed
Parts:
- removed SW7: SW_SPDT, swtiches_spdt_dpdt:TL3XWO, symbol Switch:SW_SPDT
- added SW7: SW_DPDT_x2, swtiches_spdt_dpdt:TL4XWO, symbol Switch:SW_DPDT_x2
- U10: value 74LVC1G06GW -> 74LVC1G06
Connections:
- net +5V: now also F4.2, IC3.3 (A=B_I), R30.2, SW2.3 (C), SW3.1 (A), U10.5 (VCC), U12.5 (VCC), U14.5 (VCC), U29.20 (VCC), U35.5 (VCC), U9.5 (VCC), SW7.3 (C)
- net DPX_LOOP_INH_CNTRL: now also SW7.2 (B)
- net GND: now also U29.1 (~1OE), U29.19 (~2OE), SW7.1 (A); no longer U10.5 (VCC), U12.5 (VCC), U14.5 (VCC), U35.5 (VCC), U9.5 (VCC)
- net 2Y3: now reaches U19.9 (2Y3), U35.2
- new net DUPLEX_MIX: SW7.4 (A)
- new net DUPLEX_MIX_SW: SW7.5 (B)
Other:
- moved on the sheet: U35

Commit message: all components placed on pcb
Parts:
- removed C6: 10n, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- removed C7: 47u, Capacitor_Tantalum_SMD:CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder, symbol Device:C_Polarized
- removed R48, R49: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- removed U26: NE555D, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Timer:NE555D
- added C59: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C
- added D21, D22, D23, D24: LED, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, symbol Device:LED
- added H1, H2: MountingHole, MountingHole:MountingHole_3.2mm_M3, symbol Mechanical:MountingHole
- added R123, R124, R125, R126: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
Connections:
- net +5V: now also Q1.2 (E), R26.2, U6.4, C59.1
- net CNTR0: now also D22.2 (A)
- net CNTR1: now also D21.2 (A)
- net CNTR2: now also D23.2 (A)
- net CNTR3: now also D24.2 (A)
- net GND: now also C59.2, R123.2, R124.2, R125.2, R126.2
- net TAIL0: now reaches IC3.9 (B0), R44.2, SW6.1
- net TAIL3: now reaches IC3.1 (B3), R50.2, SW6.4
- net TAIL1: now reaches IC3.11 (B1), R46.2, SW6.2
- net TAIL2: now reaches IC3.14 (B2), R47.2, SW6.3
- new net: D24.1 (K), R126.1
- new net: D21.1 (K), R123.1
- new net: D23.1 (K), R125.1
- new net: D22.1 (K), R124.1
Other:
- added sheet 555Timer (fm-rpt-control-555.kicad_sch)

Commit message: some traces in logic section
Parts:
- removed D16: LED_Dual_AKKA, LED:LED_MENTOR_1801, symbol Device:LED_Dual_AKKA
- added D16: LED_Dual_AKAK, LED:LED_MENTOR_1801, symbol Device:LED_Dual_AKAK
Connections:
- net +5V: now also IC3.6 (A=B_O); no longer IC3.3 (A=B_I)
- net CNTR0: no longer IC3.10 (A0)
- net CNTR1: no longer IC3.12 (A1)
- net CNTR2: no longer IC3.13 (A2)
- net CNTR3: no longer IC3.15 (A3)
- net DPX_TX_TAIL_CLR: now also IC3.3 (A=B_I); no longer IC3.6 (A=B_O)
- net DUPLEX_PTT_ISOL: now also D16.1 (A1)
- net GND: now also IC3.5 (A>B_O), IC3.7 (A<B_O); no longer IC3.2 (A<B_I), IC3.4 (A>B_I)
- net SIMPLEX_PTT_ISOL: now also D16.3 (A2)
- net TAIL0: no longer IC3.9 (B0)
- net TAIL1: no longer IC3.11 (B1)
- net TAIL2: no longer IC3.14 (B2)
- net TAIL3: no longer IC3.1 (B3)
- net at R52.1: now also D16.2 (K1)
- net at R53.1: now also D16.4 (K2)
Changed lines of the file:
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@@
     (pin "8")
   )
+  (symbol (lib_id "Device:LED_Dual_AKAK") (at 374.65 109.22 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D16" (id 0) (at 374.523 99.0432 0))
+    (property "Value" "LED_Dual_AKAK" (id 1) (at 374.523 101.5801 0))
+    (property "Footprint" "LED:LED_MENTOR_1801" (id 2) (at 375.412 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 375.412 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (pin "3")
+    (pin "4")
+  )
   (symbol (lib_id "paratnc_cp_import:GND") (at 340.36 245.11 90) (mirror x) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "1")
   )
-  (symbol (lib_id "and_or_xor:74HC08D") (at 386.08 198.12 0) (unit 5)
+  (symbol (lib_id "and_or_xor:74HC08D") (at 386.08 198.12 0) (mirror y) (unit 5)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U21" (id 0) (at 391.16 186.69 0))
-    (property "Value" "74HC08D" (id 1) (at 391.16 189.23 0))
+    (property "Reference" "U21" (id 0) (at 381 186.69 0))
+    (property "Value" "74HC08D" (id 1) (at 381 189.23 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 386.08 198.12 0)
       (effects (font (size 1.27 1.27)) hide)
@@
     (pin "2")
   )
-  (symbol (lib_id "sterownik_eagle_import:7485D") (at 363.22 68.58 0) (unit 1)
+  (symbol (lib_id "sterownik_eagle_import:7485D") (at 363.22 68.58 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "IC3" (id 0) (at 363.22 51.9974 0)
+    (property "Reference" "IC3" (id 0) (at 363.22 48.5974 0)
       (effects (font (size 1.778 1.5113)))
     )
-    (property "Value" "74HC85D" (id 1) (at 353.06 88.9 0)
-      (effects (font (size 1.778 1.5113)) (justify left bottom))
+    (property "Value" "74HC85D" (id 1) (at 363.22 51.9974 0)
+      (effects (font (size 1.778 1.5113)))
     )
     (property "Footprint" "Package_SO:SO-16_3.9x9.9mm_P1.27mm" (id 2) (at 363.22 68.58 0)
@@
     (pin "9")
   )
-  (symbol (lib_id "Device:LED_Dual_AKKA") (at 374.65 109.22 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "D16" (id 0) (at 374.523 99.0432 0))
-    (property "Value" "LED_Dual_AKKA" (id 1) (at 374.523 101.5801 0))
-    (property "Footprint" "LED:LED_MENTOR_1801" (id 2) (at 375.412 109.22 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 375.412 109.22 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (pin "4")
-  )
   (symbol (lib_id "Device:R") (at 300.99 176.53 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
       (reference "D15") (unit 1) (value "1N4148W") (footprint "Diode_SMD:D_SOD-123")
     )
-    (path "/9090b132-e544-4319-9fad-9568bbd33a19"
-      (reference "D16") (unit 1) (value "LED_Dual_AKKA") (footprint "LED:LED_MENTOR_1801")
+    (path "/311f9ec6-de8b-4f6c-a874-5b0fcff90237"
+      (reference "D16") (unit 1) (value "LED_Dual_AKAK") (footprint "LED:LED_MENTOR_1801")
     )
     (path "/b879b7bc-53ac-46d7-aad9-93d9e37cf0ee"
