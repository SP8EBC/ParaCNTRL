File: fm-rpt-control-roger-beep.kicad_sch (KiCad schematic)
At the start: 21 parts, among them Q5 BC858, Q6 BC858, Q7 BC848, U31 HEF4093B

Commit message: controlling to_pc_retransmission line
Parts:
- renumbered D18 to D19, U31 to U32
Changed lines of the file:
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@@
   (symbol (lib_id "4xxx:HEF4093B") (at 162.56 119.38 0) (unit 4)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U31" (id 0) (at 162.56 111.8702 0))
+    (property "Reference" "U32" (id 0) (at 162.56 111.8702 0))
     (property "Value" "HEF4093B" (id 1) (at 162.56 114.4071 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 162.56 119.38 0)
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 167.64 86.36 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U31" (id 0) (at 167.64 78.8502 0))
+    (property "Reference" "U32" (id 0) (at 167.64 78.8502 0))
     (property "Value" "HEF4093B" (id 1) (at 167.64 81.3871 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 167.64 86.36 0)
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 127 95.25 0) (mirror y) (unit 3)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U31" (id 0) (at 127 87.7402 0))
+    (property "Reference" "U32" (id 0) (at 127 87.7402 0))
     (property "Value" "HEF4093B" (id 1) (at 127 90.2771 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 127 95.25 0)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 214.63 104.14 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND068" (id 0) (at 214.63 104.14 0)
+    (property "Reference" "#GND069" (id 0) (at 214.63 104.14 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 214.63 87.63 0) (unit 5)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U31" (id 0) (at 220.472 86.7953 0)
+    (property "Reference" "U32" (id 0) (at 220.472 86.7953 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 140.97 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND063" (id 0) (at 140.97 138.43 0)
+    (property "Reference" "#GND064" (id 0) (at 140.97 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 196.85 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND067" (id 0) (at 196.85 138.43 0)
+    (property "Reference" "#GND068" (id 0) (at 196.85 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 113.03 90.17 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND062" (id 0) (at 113.03 90.17 0)
+    (property "Reference" "#GND063" (id 0) (at 113.03 90.17 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 182.88 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND066" (id 0) (at 182.88 138.43 0)
+    (property "Reference" "#GND067" (id 0) (at 182.88 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Diode:1N4148W") (at 149.86 83.82 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "D18" (id 0) (at 149.86 78.8502 0))
+    (property "Reference" "D19" (id 0) (at 149.86 78.8502 0))
     (property "Value" "1N4148W" (id 1) (at 149.86 81.3871 0))
     (property "Footprint" "Diode_SMD:D_SOD-123" (id 2) (at 149.86 88.265 0)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 149.86 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND064" (id 0) (at 149.86 138.43 0)
+    (property "Reference" "#GND065" (id 0) (at 149.86 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 168.91 95.25 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND065" (id 0) (at 168.91 95.25 0)
+    (property "Reference" "#GND066" (id 0) (at 168.91 95.25 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 128.27 77.47 0) (unit 2)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U31" (id 0) (at 128.27 69.9602 0))
+    (property "Reference" "U32" (id 0) (at 128.27 69.9602 0))
     (property "Value" "HEF4093B" (id 1) (at 128.27 72.4971 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 128.27 77.47 0)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 107.95 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND061" (id 0) (at 107.95 138.43 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "#GND062" (id 0) (at 107.95 138.43 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: logic ics, relays and relay driving electronics, voltage regulators placed
Parts:
- added R62, R63: 0, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added R65, R66: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R
- added U32: 74AHC1G32GW, Package_TO_SOT_SMD:SOT-353_SC-70-5_Handsoldering, symbol 74xGxx:74AHC1G32
- RV3: footprint Potentiometer_SMD:Potentiometer_Bourns_3314J_Vertical -> potentiometers:Potentiometer_SRpassives_1028F
- renumbered R62 to R64, R63 to R67, R64 to R68, U32 to U31
Connections:
- net GND: now also R65.1, R66.1, U32.3 (GND)
- net ROGER_PTT_INPUT: now also U32.4
- net +5V renamed VDDA
- new net: R63.1, R65.2, U32.1
- new net: R62.1, R66.2, U32.2
- new net RETRANSMIT_DBCED: R62.2
- new net RETRANSMIT_NEVER_DBCED: R63.2
- new net VCC: U32.5 (VCC)
- no-connect marks 0 -> 1
