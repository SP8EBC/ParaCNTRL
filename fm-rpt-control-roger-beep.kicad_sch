File: fm-rpt-control-roger-beep.kicad_sch (KiCad schematic)
At the start: 21 parts, among them Q5 BC858, Q6 BC858, Q7 BC848, U30 HEF4093B

Commit message: PCB dimenstions set and db/din sockets, pots, switches and leds placed
Parts:
- U31: renamed from U30; footprint Package_SO:SO-8_3.9x4.9mm_P1.27mm -> Package_SO:SO-14_3.9x8.65mm_P1.27mm
- renumbered D11 to D18, R52 to R57, R53 to R58, R54 to R59, R55 to R60, R56 to R61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
Other:
- title: Roger Beep generator for FM repeater -> ParaCNTRL - FM repeater controller made of 74xx and analog
Changed lines of the file:
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@@
   (paper "A4")
   (title_block
-    (title "Roger Beep generator for FM repeater")
+    (title "ParaCNTRL - FM repeater controller made of 74xx and analog")
     (date "2023-02-23")
     (rev "A")
     (company "ML Elektronika Mateusz Lubecki")
+    (comment 1 "Roger Beep generator")
   )
   (junction (at 149.86 116.84) (diameter 0) (color 0 0 0 0)
@@
   (symbol (lib_id "Device:R") (at 127 118.11 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R55" (id 0) (at 127 113.3942 90))
+    (property "Reference" "R60" (id 0) (at 127 113.3942 90))
     (property "Value" "5k1" (id 1) (at 127 115.9311 90))
     (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 127 119.888 90)
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 162.56 119.38 0) (unit 4)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U30" (id 0) (at 162.56 111.8702 0))
+    (property "Reference" "U31" (id 0) (at 162.56 111.8702 0))
     (property "Value" "HEF4093B" (id 1) (at 162.56 114.4071 0))
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 162.56 119.38 0)
+    (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 162.56 119.38 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 167.64 86.36 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U30" (id 0) (at 167.64 78.8502 0))
+    (property "Reference" "U31" (id 0) (at 167.64 78.8502 0))
     (property "Value" "HEF4093B" (id 1) (at 167.64 81.3871 0))
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 167.64 86.36 0)
+    (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 167.64 86.36 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 100.33 66.04 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R52" (id 0) (at 100.33 61.3242 90))
+    (property "Reference" "R57" (id 0) (at 100.33 61.3242 90))
     (property "Value" "5k1" (id 1) (at 100.33 63.8611 90))
     (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 100.33 67.818 90)
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 127 95.25 0) (mirror y) (unit 3)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U30" (id 0) (at 127 87.7402 0))
+    (property "Reference" "U31" (id 0) (at 127 87.7402 0))
     (property "Value" "HEF4093B" (id 1) (at 127 90.2771 0))
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 127 95.25 0)
+    (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 127 95.25 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 214.63 104.14 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND066" (id 0) (at 214.63 104.14 0)
+    (property "Reference" "#GND068" (id 0) (at 214.63 104.14 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 214.63 87.63 0) (unit 5)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U30" (id 0) (at 220.472 86.7953 0)
+    (property "Reference" "U31" (id 0) (at 220.472 86.7953 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 214.63 87.63 0)
+    (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 214.63 87.63 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 113.03 81.28 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R54" (id 0) (at 114.808 80.4453 0)
+    (property "Reference" "R59" (id 0) (at 114.808 80.4453 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 140.97 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND061" (id 0) (at 140.97 138.43 0)
+    (property "Reference" "#GND063" (id 0) (at 140.97 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 196.85 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND065" (id 0) (at 196.85 138.43 0)
+    (property "Reference" "#GND067" (id 0) (at 196.85 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 113.03 90.17 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND060" (id 0) (at 113.03 90.17 0)
+    (property "Reference" "#GND062" (id 0) (at 113.03 90.17 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 140.97 111.76 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R57" (id 0) (at 142.748 110.9253 0)
+    (property "Reference" "R62" (id 0) (at 142.748 110.9253 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Device:R") (at 177.8 119.38 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R58" (id 0) (at 177.8 114.6642 90))
+    (property "Reference" "R63" (id 0) (at 177.8 114.6642 90))
     (property "Value" "10k" (id 1) (at 177.8 117.2011 90))
     (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 177.8 121.158 90)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 182.88 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND064" (id 0) (at 182.88 138.43 0)
+    (property "Reference" "#GND066" (id 0) (at 182.88 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Diode:1N4148W") (at 149.86 83.82 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "D11" (id 0) (at 149.86 78.8502 0))
+    (property "Reference" "D18" (id 0) (at 149.86 78.8502 0))
     (property "Value" "1N4148W" (id 1) (at 149.86 81.3871 0))
     (property "Footprint" "Diode_SMD:D_SOD-123" (id 2) (at 149.86 88.265 0)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 149.86 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND062" (id 0) (at 149.86 138.43 0)
+    (property "Reference" "#GND064" (id 0) (at 149.86 138.43 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 127 127 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R56" (id 0) (at 127 122.2842 90))
+    (property "Reference" "R61" (id 0) (at 127 122.2842 90))
     (property "Value" "4k7" (id 1) (at 127 124.8211 90))
     (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 127 128.778 90)
@@
   (symbol (lib_id "Device:R") (at 107.95 130.81 180) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R53" (id 0) (at 109.728 129.9753 0)
+    (property "Reference" "R58" (id 0) (at 109.728 129.9753 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 168.91 95.25 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND063" (id 0) (at 168.91 95.25 0)
+    (property "Reference" "#GND065" (id 0) (at 168.91 95.25 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "4xxx:HEF4093B") (at 128.27 77.47 0) (unit 2)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U30" (id 0) (at 128.27 69.9602 0))
+    (property "Reference" "U31" (id 0) (at 128.27 69.9602 0))
     (property "Value" "HEF4093B" (id 1) (at 128.27 72.4971 0))
-    (property "Footprint" "Package_SO:SO-8_3.9x4.9mm_P1.27mm" (id 2) (at 128.27 77.47 0)
+    (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 128.27 77.47 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 189.23 119.38 90) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R59" (id 0) (at 189.23 114.6642 90))
+    (property "Reference" "R64" (id 0) (at 189.23 114.6642 90))
     (property "Value" "100k" (id 1) (at 189.23 117.2011 90))
     (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 189.23 121.158 90)
@@
   (symbol (lib_id "paratnc_cp_import:GND") (at 107.95 138.43 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#GND059" (id 0) (at 107.95 138.43 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "#GND061" (id 0) (at 107.95 138.43 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
