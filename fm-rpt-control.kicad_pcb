File: fm-rpt-control.kicad_pcb (KiCad board)
At the start: 2 copper layers, 159.3 x 158.8 mm, 301 parts, among them IC1 74HC107D, IC2 74HC393M, IC3 74HC85D, IC4 LM567CH, IC5 74HC107D, J1 DUPLEX_RX, J2 SIMPLEX, J5 Conn_01x03_Male, J8 DUPLEX_TX, J9 Jack-DC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

Commit message: all components placed on pcb
Parts:
- added C59: 100n, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (110.6, 145.7)
- added C60: 47u, Capacitor_Tantalum_SMD:CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder, F.Cu at (95.8, 116.8)
- added D21: LED, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (118.0, 119.5)
- added D22: LED, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (120.1, 119.5)
- added D23: LED, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (116.0, 119.5)
- added D24: LED, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (114.0, 119.5)
- added H1: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (70.5, 114.7)
- added H2: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (142.8, 95.7)
- added J3: AudioJack3, Connector_Audio:Jack_3.5mm_Lumberg_1503_07_Horizontal, F.Cu at (34.2, 170.1)
- added R123: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (118.1, 115.7)
- added R124: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (120.1, 115.7)
- added R125: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (116.0, 115.7)
- added R126: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (114.0, 115.7)
- C7: value 47u -> 100n; footprint Capacitor_Tantalum_SMD:CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- D17, D6: moved to B.Cu
- moved U24 404.1 mm to (160.8, 151.6), turned to -90 degrees
- moved D1 368.7 mm to (170.4, 111.5)
- moved D2 367.6 mm to (170.4, 119.0)
- moved R6 350.7 mm to (170.3, 113.5), turned to 180 degrees
- moved U26 349.0 mm to (103.5, 114.0)
- moved C13 347.3 mm to (153.5, 132.9)
- moved D8 344.1 mm to (131.7, 64.1)
- moved R2 342.2 mm to (145.5, 69.0), turned to -90 degrees
- moved C7 333.7 mm to (97.3, 113.0), turned to 90 degrees
- moved C24 332.8 mm to (84.3, 133.3), turned to 90 degrees
- moved C9 331.9 mm to (124.5, 133.1)
- moved RV4 326.4 mm to (60.0, 108.7), turned to 180 degrees
- moved C41 326.2 mm to (83.5, 154.1), turned to 180 degrees
- moved R95 323.3 mm to (86.5, 129.7), turned to 90 degrees
- moved R4 322.6 mm to (135.7, 69.0), turned to -90 degrees
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Connections:
- net Net-(C6-Pad1) renamed /555Timer/555_CV
- net Net-(IC3-Pad1) renamed /TAIL3
- net Net-(IC3-Pad11) renamed /TAIL1
- net Net-(IC3-Pad14) renamed /TAIL2
- net Net-(IC3-Pad9) renamed /TAIL0
- C7 pad 1: Net-(C7-Pad1) -> +5V
- Q1 pad 2: Net-(Q1-Pad2) -> +5V
- R26 pad 2: Net-(Q1-Pad2) -> +5V
- R49 pad 1: Net-(C7-Pad1) -> /555Timer/555_THR
- U26 pad 2: Net-(C7-Pad1) -> /555Timer/555_THR
- U26 pad 4: unconnected-(U26-Pad4) -> +5V
- U26 pad 6: Net-(C7-Pad1) -> /555Timer/555_THR
- U39 pad 1: /AudioFilters/TONE_DET -> (no net)
- U39 pad 2: Net-(IC5-Pad9) -> (no net)
- U39 pad 5: (no net) -> /AudioFilters/TONE_DET
- U39 pad 6: (no net) -> Net-(IC5-Pad9)
- U6 pad 4: unconnected-(U6-Pad4) -> +5V
Other:
- board text added: "ACCESSORY CONNECTOR"
- board text added: "CNTR_CLR"
- board text added: "DUPLEX"
- board text added: "DURATION"
- board text added: "ParaCNTRL Rev-A Mateusz Lubecki Bielsko-Biała"
- board text added: "ROGER_PTT_SW"
- board text added: "SPX+PC"
- board text added: "SPX_MSTR_ENABLE"
- board text added: "TONE"
- board text added: "TONE DETECT TUNE"
- board text added: "TX TAIL COUNTER"
- board text added: "TX TAIL LENGHT SECONDS"
- board text added: "VOLUME"
- board text added: "~{DPX_INHIBIT}"
- board text added: "~{SPX_INHIBIT}"

Commit message: some traces in logic section
Parts:
- D16: value LED_Dual_AKKA -> LED_Dual_AKAK
- moved F2 36.9 mm to (169.7, 91.4)
- moved F3 28.9 mm to (165.5, 91.4)
- moved R34 1.71 mm to (98.2, 151.2)
- moved C13 1.44 mm to (152.1, 133.3), turned to -90 degrees
- moved C11 1.39 mm to (137.7, 145.9), turned to -90 degrees
- moved C9 1.37 mm to (123.2, 133.3), turned to -90 degrees
- moved C59 0.90 mm to (109.8, 145.9), turned to -90 degrees
Connections:
- D16 pad 3: Net-(D16-Pad3) -> /SIMPLEX_PTT_ISOL
- D16 pad 4: /SIMPLEX_PTT_ISOL -> Net-(R53-Pad1)
- IC3 pad 1: /TAIL3 -> unconnected-(IC3-Pad1)
- IC3 pad 10: /CNTR0 -> unconnected-(IC3-Pad10)
- IC3 pad 11: /TAIL1 -> unconnected-(IC3-Pad11)
- IC3 pad 12: /CNTR1 -> unconnected-(IC3-Pad12)
- IC3 pad 13: /CNTR2 -> unconnected-(IC3-Pad13)
- IC3 pad 14: /TAIL2 -> unconnected-(IC3-Pad14)
- IC3 pad 15: /CNTR3 -> unconnected-(IC3-Pad15)
- IC3 pad 2: GND -> unconnected-(IC3-Pad2)
- IC3 pad 3: +5V -> /DPX_TX_TAIL_CLR
- IC3 pad 4: GND -> unconnected-(IC3-Pad4)
- IC3 pad 5: unconnected-(IC3-Pad5) -> GND
- IC3 pad 6: /DPX_TX_TAIL_CLR -> +5V
- IC3 pad 7: unconnected-(IC3-Pad7) -> GND
- IC3 pad 9: /TAIL0 -> unconnected-(IC3-Pad9)
- R53 pad 1: Net-(D16-Pad3) -> Net-(R53-Pad1)
Routing:
- net +5V: track 0.00 -> 381.7 mm, vias 0 -> 22
- net CLK: track 0.00 -> 131.8 mm, vias 0 -> 10
- net /DPX_TX_TAIL: track 0.00 -> 112.1 mm, vias 0 -> 7
- net RETRANSMIT_NEVER_DBCED: track 0.00 -> 101.9 mm, vias 0 -> 6
- net /DPX_PTT_FROM_ACC: track 0.00 -> 92.1 mm, vias 0 -> 2
- net /SPX_PTT_AFT_INHIBIT: track 0.00 -> 90.0 mm, vias 0 -> 4
- net /ROGER_PTT_SW: track 0.00 -> 82.3 mm, vias 0 -> 5
- net MAIN_RETRANSMIT: track 0.00 -> 79.0 mm, vias 0 -> 6
- net /~{SPX_INHIBIT}: track 0.00 -> 72.1 mm, vias 0 -> 2
- net /DUPLEX_PTT_ISOL: track 0.00 -> 67.7 mm, vias 0 -> 2
- net Net-(U21-Pad4): track 0.00 -> 63.4 mm, vias 0 -> 4
- net /CNTR_CLR: track 0.00 -> 60.8 mm, vias 0 -> 2
- net /DPX_PTT_CNTRL_AFT_INIBIT: track 0.00 -> 56.0 mm, vias 0 -> 4
- net Net-(U24-Pad3): track 0.00 -> 55.2 mm, vias 0 -> 4
- net /DPX_PTT_DIR_FROM_RMT: track 0.00 -> 54.1 mm, vias 0 -> 4
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