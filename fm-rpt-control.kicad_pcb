# Repository SP8EBC/ParaCNTRL

File README.md:

# ParaCNTRL
FM repeater controller build w/o using any microntroller, Arduino or even Raspberry PI ;) Only op-amps and 74HCxx inside ;)

## KiCad design fm-rpt-control.kicad_pcb

Parts:
ACC1: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical
C1, C2, C3, C10: C_Polarized; C_Radial_D6.3mm_H7.0mm_P2.50mm
C4, C5: 120u; C_Radial_D6.3mm_H7.0mm_P2.50mm
C8: 330u; CP_EIA-7343-31_Kemet-D_Pad2.25x2.55mm_HandSolder
C9, C11, C12, C13, C14, C15, C59: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D21, D22, D23, D24: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6, D7, D8, D13, D14, D17: ESDA6V1-5SC6; SOT-23-6
D9, D10, D11, D12, D15: 1N4148W; D_SOD-123
D16: LED_Dual_AKAK; LED_MENTOR_1801
D18: QLS6B-FKW; LED_MENTOR_1882
F1, F4: Polyfuse; Fuse_2010_5025Metric_Pad1.52x2.65mm_HandSolder
H1, H2: MountingHole; MountingHole_3.2mm_M3
IC1: 74HC107D; SO-14_3.9x8.65mm_P1.27mm
IC2: 74HC393M; SO14
IC3: 74HC85D; SO-16_3.9x9.9mm_P1.27mm
J1: DUPLEX_RX; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
J2: SIMPLEX; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
J5: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J8: DUPLEX_TX; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
K1: RM12-3011-35-1005; Relay_SPDT_Relpol_RM12
K2: RM12__SPDT; Relay_SPDT_Relpol_RM12
Q1, Q2, Q3: BC856; SOT-23
Q4: BC846; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R19, R35, R44, R46, R47, R50, R52, R53, R54, R55, R56, R123, R124, R125, R126: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12, R13, R14, R15: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R21: 600; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R18, R30, R32, R33, R34, R41: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22, R23, R24, R26, R28, R29: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R27, R31: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36, R37, R38, R39, R40, R42, R43, R51: 660; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R45: 51; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN1: 22k; R_Array_SIP9
SW1: DEBOUNCE; Ninigi_MSS-2235S
SW2: SPX_ENABLE; TL3XWO
SW3: SPX_INHIBIT; TL3XWO
SW4: ROGER; TL4XWO
SW5: TX_TAIL; TL3XWO
SW6: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW7: SW_DPDT_x2; TL4XWO
SW8: SKHHLRA010; SW_Tactile_SKHH_Angled
SW9, SW10: SW_Push_DPDT; Ninigi_SS22F03-G6
TR1, TR2, TR3, TR4, TR5, TR6: CRIYCHLEY9000; NORMAL
U1, U2, U3, U4, U5, U6, U27, U28, U30: SFH617A-1; SMDIP-4_W9.53mm
U7, U19, U29: 74HC244D,652; SOIC127P1032X265-20N; MPN 74HC244D,652
U8: 74HC02; SOIC-14_3.9x8.7mm_P1.27mm
U9: 74AHC1G08GV; TSOP-5_1.65x3.05mm_P0.95mm
U10: 74LVC1G06; SOT-353_SC-70-5_Handsoldering
U11, U13, U25: 74AHC04; SOIC-14_3.9x8.7mm_P1.27mm
U12, U14: 74LVC1G06GW; SOT-353_SC-70-5_Handsoldering
U15: 74HC74; SOIC-14_3.9x8.7mm_P1.27mm
U16, U20, U21, U22: 74HC08D; SO-14_3.9x8.65mm_P1.27mm
U17, U18, U23: 74HC32D; SO-14_3.9x8.65mm_P1.27mm
U24: 74HC86; SO-14_3.9x8.65mm_P1.27mm
U35: 74AHC1G32GW; SOT-353_SC-70-5_Handsoldering
X1: REMOTE; MAB8SH
X2: PC; MAB5SH

Connections:
+5V: C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C59.1, F4.2, IC1.14 (VCC), IC2.14 (VCC), IC3.3 (A=B_I), IC3.16 (VCC), Q1.2 (E), Q2.2 (E), Q3.2 (E), R1.2, R2.2, R3.2, R4.2, R5.2, R23.2, R26.2, R28.2, R30.2, R44.1, R46.1, R47.1, R50.1, SW1.2 (B), SW2.3 (C), SW3.1 (A), SW7.3 (C), SW8.1, U1.4, U2.4, U3.4, U6.4, U7.20 (VCC), U8.14 (VCC), U9.5 (VCC), U10.5 (VCC), U11.14 (VCC), U12.5 (VCC), U13.14 (VCC), U14.5 (VCC), U15.1 (~R), U15.4 (~S), U15.14 (VCC), U16.14 (VCC), U17.14 (VCC), U18.14 (VCC), U20.14 (VCC), U21.14 (VCC), U22.14 (VCC), U23.14 (VCC), U24.14 (VCC), U25.14 (VCC), U29.20 (VCC), U35.5 (VCC); also elsewhere on the board
+VDC: F1.2; also elsewhere on the board
/2Y3: U19.9 (2Y3), U35.2
/ACC_5V: ACC1.19, F4.1
/ACC_+V: ACC1.17, F1.1
/CNTR0: D22.2 (A), IC2.3 (QA), IC3.10 (A0)
/CNTR1: D21.2 (A), IC2.4 (QB), IC3.12 (A1)
/CNTR2: D23.2 (A), IC2.5 (QC), IC3.13 (A2)
/CNTR3: D24.2 (A), IC2.6 (QD), IC3.15 (A3)
/CNTR_CLR: D5.2 (A), IC2.2 (CLR), U25.2
/DBC_CNTRL: R32.1, SW1.1 (A), U16.5
/DPX_CARRIER_DET: D6.5 (IO4), J1.6, R11.1
/DPX_CARRIER_DET_ISOL: J5.3, R17.1, U1.3
/DPX_CTCSS_DET: D6.6 (IO5), J1.1, R12.1
/DPX_CTCSS_DET_ISOL: J5.1, R18.1, U2.3
/DPX_FLAT_PTT: D17.4 (IO3), J8.9, SW10.3 (C)
/DPX_FLAT_TX_AUD: D17.6 (IO5), J8.2, SW10.6 (C)
/DPX_INHIBIT_FROM_ACC: U13.3, U19.18 (1Y0)
/DPX_LOOP_INH_CNTRL: SW7.2 (B), U35.1
/DPX_LOOP_INH_FROM_ACC: U8.6, U35.4
/DPX_PTT: D17.5 (IO4), J8.4, SW10.1 (A)
/DPX_PTT_CNTRL: U20.5, U23.6
/DPX_PTT_CNTRL_AFT_INIBIT: U20.6, U23.9
/DPX_PTT_CNTRL_WO_ROGER: U23.3, U23.4
/DPX_PTT_DIR_FROM_RMT: U13.12, U23.10
/DPX_PTT_FROM_ACC: U19.16 (1Y1), U23.13
/DPX_RETRN_DBC: U15.5 (Q), U16.4
/DPX_RX_AUD: C1.1, D6.4 (IO3), J1.3
/DPX_TX_AUD: D17.3 (IO2), J8.5, SW10.4 (A)
/DPX_TX_TAIL: IC1.3 (Q), SW5.1 (A), U24.1
/DPX_TX_TAIL_CLR: IC1.13 (~RST), IC3.6 (A=B_O)
/DUPLEX_PTT_ISOL: D16.1 (A1), R45.2, U23.11, U29.17 (2A0)
/IACC_DPX_INHIBIT: ACC1.6, D13.4 (IO3), RN1.2 (R1), U19.2 (1A0)
/IACC_DPX_LOOP_INHIBIT: ACC1.22, D14.6 (IO5), RN1.9 (R8), U19.11 (2A3)
/IACC_DPX_MUTE: ACC1.21, R41.1, U29.11 (2A3)
/IACC_DPX_PTT: ACC1.10, D13.6 (IO5), RN1.4 (R3), U19.4 (1A1)
/IACC_RETRNSMT: ACC1.18, D14.4 (IO3), RN1.7 (R6), U19.13 (2A2)
/IACC_RETRNSMT_ND: ACC1.20, D14.5 (IO4), RN1.8 (R7), U19.8 (1A3)
/IACC_SPX_ENABLE: ACC1.8, D13.5 (IO4), RN1.3 (R2), U19.17 (2A0)
/IACC_SPX_INHIBIT: ACC1.14, D14.3 (IO2), RN1.6 (R5), U19.6 (1A2)
/IACC_SPX_PTT: ACC1.12, D14.1 (IO1), RN1.5 (R4), U19.15 (2A1)
/OACC_DPX_PTT: ACC1.7, R37.1
/OACC_DPX_RETRN: ACC1.13, R40.1
/OACC_DPX_RETRN_ND: ACC1.5, R36.1
/OACC_SPX_ENABLE: ACC1.11, R39.1
/OACC_SPX_PTT: ACC1.9, R38.1
/PC_FROM_AUD: C4.1, X2.1
/PC_FROM_PTT: D10.2 (A), X2.3
/PC_TO_AUD: C5.1, X2.4
/PC_TO_RETR_ACTIVE: R15.1, X2.5
/RETRANSMIT: J5.2, Q3.3 (C), U15.2 (D), U16.1
/RETRANSMIT_FROM_ACC: R31.1, U19.7 (2Y2)
/RETRNSMIT_ND_FROM_ACC: U14.2, U19.12 (1Y3)
/RMT_ACC_PIN4: ACC1.4, X1.4
/RMT_ACC_PIN5: ACC1.2, X1.5
/ROGER_PTT_SW: D3.2 (A), SW4.5 (B), U18.4, U23.5
/SIMPLEX_PTT_ISOL: D16.3 (A2), R20.2, U18.11, U29.4 (1A1)
/SPX_CTCSS_DET: D7.6 (IO5), D9.2 (A), J2.1
/SPX_CTCSS_DET_ISOL: R19.1, U3.3, U8.9, U9.1
/SPX_ENABLE_CNTRL: R27.1, U9.2, U20.3, U29.15 (2A1)
/SPX_ENABLE_FROM_ACC: U19.3 (2Y0), U20.9
/SPX_FLAT_PTT: D7.3 (IO2), J2.9, SW9.6 (C)
/SPX_FLAT_TX_AUD: D7.4 (IO3), J2.2, SW9.3 (C)
/SPX_INHIBIT_CNTRL: SW3.2 (B), U21.5
/SPX_INHIBIT_FROM_ACC: U8.3, U19.14 (1Y2)
/SPX_MSTR_ENABLE: D4.2 (A), U20.2, U20.11, U21.2
/SPX_PIN6: J2.6, U28.4
/SPX_PIN8: J2.8, U27.4
/SPX_PTT: D7.1 (IO1), J2.4, SW9.4 (A)
/SPX_PTT_AFT_INHIBIT: U18.1, U21.8
/SPX_PTT_CNTRL: U21.3, U21.9
/SPX_PTT_FROM_ACC: U18.13, U19.5 (2Y1)
/SPX_RX_AUD: C2.1, D7.5 (IO4), J2.3
/SPX_TX_AUD: J2.5, SW9.1 (A)
/TAIL0: IC3.9 (B0), R44.2, SW6.1
/TAIL1: IC3.11 (B1), R46.2, SW6.2
/TAIL2: IC3.14 (B2), R47.2, SW6.3
/TAIL3: IC3.1 (B3), R50.2, SW6.4
/~DBC_CNTRL: R33.1, SW1.3 (C), U16.2
/~DPX_INHIBIT_FROM_RMT: U7.18 (1Y0), U17.12
/~DPX_INHIBIT: D1.2 (A), R24.1, U17.11, U20.4
/~DPX_LOOP_INH_FROM_RMT: U7.9 (2Y3), U13.11
/~DPX_MUTE: R29.1, U25.4
/~DPX_PTT_DIR_FROM_RMT: U7.12 (1Y3), U13.13
/~RETRANSMIT_NEVER_DBCED: R30.1, U10.4, U12.4, U13.1, U14.4
/~RMT_DIR_DUPLEX_PTT: D8.3 (IO2), R2.1, U7.8 (1A3), X1.8
/~RMT_DIR_SIMPLEX_PTT: D8.4 (IO3), R1.1, U7.6 (1A2), X1.3
/~RMT_DPX_INHIBIT: D8.6 (IO5), R4.1, U7.2 (1A0), X1.7
/~RMT_DPX_LOOP_INHIBIT: D8.1 (IO1), R3.1, U7.11 (2A3), X1.6
/~RMT_SPX_INHIBIT: D8.5 (IO4), R5.1, U7.4 (1A1), X1.1
/~SPX_INHIBIT_FROM_RMT: U7.16 (1Y1), U13.5
/~SPX_INHIBIT: D2.2 (A), U20.1, U21.6, U21.10
/~SPX_PTT_DIR_FROM_RMT: U7.14 (1Y2), U13.9
CLK: D18.1 (AB), IC1.12 (~CLK), IC2.1 (A), U15.3 (C); also elsewhere on the board
DPX_RX_ISOL: ACC1.23, K1.12, TR1.P$4
DPX_RX_ISOL_SW: K1.11; also elsewhere on the board
DPX_TX_ISOL: ACC1.25, TR6.P$1
DUPLEX_MASTER_AUD: ACC1.26; also elsewhere on the board
DUPLEX_MIX: SW7.4 (A); also elsewhere on the board
DUPLEX_MIX_SW: SW7.5 (B); also elsewhere on the board
GND: ACC1.15, ACC1.16, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C59.2, D8.2 (GND), D11.2 (A), D12.2 (A), D13.2 (GND), D14.2 (GND), IC1.4 (K), IC1.7 (GND), IC2.7 (GND), IC3.2 (A<B_I), IC3.4 (A>B_I), IC3.8 (GND), K1.14, K1.A1, K2.A1, Q4.2 (E), R6.1, R7.1, R8.1, R9.1, R10.1, R17.2, R18.2, R19.2, R22.1, R32.2, R33.2, R34.1, R35.1, R41.2, R52.2, R53.2, R54.2, R55.2, R56.2, R123.2, R124.2, R125.2, R126.2, RN1.1 (common), SW3.3 (C), SW6.5, SW6.6, SW6.7, SW6.8, SW7.1 (A), TR1.P$3, TR2.P$4, TR3.P$4, TR4.P$4, TR5.P$4, TR6.P$2, U4.2, U5.2, U7.1 (~1OE), U7.10 (GND), U7.19 (~2OE), U8.7 (GND), U9.3 (GND), U10.3 (GND), U11.7 (GND), U12.3 (GND), U13.7 (GND), U14.3 (GND), U15.7 (GND), U16.7 (GND), U17.7 (GND), U18.7 (GND), U19.1 (~1OE), U19.10 (GND), U19.19 (~2OE)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; also elsewhere on the board
GND1: TR4.P$2, TR5.P$2, U5.3, U6.2, X2.2, X2.PE, X2.PE@ (PE)
GND2: J1.7, TR1.P$1
GND3: D17.2 (GND), J8.7, TR6.P$4, U30.3
GNDS: D6.2 (GND), D7.2 (GND), J2.7, TR2.P$2, TR3.P$2, U1.2, U2.2, U3.2, U4.3, U27.3, U28.3
MAIN_RETRANSMIT: U11.3, U17.8, U24.2
unnamed: ACC1.1, R42.1
unnamed: ACC1.3, R43.1
unnamed: C1.2, TR1.P$2
unnamed: C2.2, TR3.P$1
unnamed: C3.1, SW9.2 (B)
unnamed: C3.2, TR2.P$1
unnamed: C4.2, TR4.P$1
unnamed: C5.2, TR5.P$1
unnamed: C8.1, D15.1 (K), R51.1, SW8.2
unnamed: C10.1, SW10.5 (B)
unnamed: C10.2, TR6.P$3
unnamed: D1.1 (K), R6.2
unnamed: D2.1 (K), R7.2
unnamed: D3.1 (K), R8.2
unnamed: D4.1 (K), R9.2
unnamed: D5.1 (K), R10.2
unnamed: D9.1 (K), R14.1
unnamed: D10.1 (K), R16.1
unnamed: D11.1 (K), K1.A2, Q2.3 (C)
unnamed: D12.1 (K), K2.A2, Q1.3 (C)
unnamed: D15.2 (A), R45.1
unnamed: D16.2 (K1), R52.1
unnamed: D16.4 (K2), R53.1
unnamed: D18.2 (KB), R56.1
unnamed: D18.4 (KR), R54.1
unnamed: D18.6 (KR), R55.1
unnamed: D21.1 (K), R123.1
unnamed: D22.1 (K), R124.1
unnamed: D23.1 (K), R125.1
unnamed: D24.1 (K), R126.1
unnamed: Q1.1 (B), R26.1, R27.2
unnamed: Q2.1 (B), R24.2, R28.1, R29.2
unnamed: Q3.1 (B), R23.1, R25.2
unnamed: Q4.1 (B), R31.2
unnamed: Q4.3 (C), R25.1
unnamed: R11.2, U1.1
unnamed: R12.2, U2.1
unnamed: R13.1, SW9.5 (B)
unnamed: R13.2, U4.4
unnamed: R14.2, U3.1
unnamed: R15.2, U5.4
unnamed: R16.2, U6.1
unnamed: R20.1, U4.1
unnamed: R21.1, U5.1
unnamed: R21.2, U8.13
unnamed: R22.2, U6.3, U8.11, U10.2
unnamed: R34.2, SW2.2 (B), U20.10
unnamed: R35.2, SW4.6 (C)
unnamed: R36.2, U29.18 (1Y0)
unnamed: R37.2, U29.3 (2Y0)
unnamed: R38.2, U29.16 (1Y1)
unnamed: R39.2, U29.5 (2Y1)
unnamed: R40.2, U29.14 (1Y2)
unnamed: R42.2, U27.1
unnamed: R43.2, U28.1
unnamed: R51.2, U30.1
unnamed: SW5.2 (B), U22.2
unnamed: SW10.2 (B), U30.4
unnamed: U8.1, U8.8
unnamed: U8.12, U11.4
unnamed: U9.4, U12.2
unnamed: U13.4, U17.13
unnamed: U8.2, U13.6
unnamed: U13.8, U18.2
unnamed: U8.5, U13.10
unnamed: U16.3, U17.4
unnamed: U16.6, U17.1
unnamed: U17.2, U17.6
unnamed: U18.6, U18.9
unnamed: U18.8, U21.1
unnamed: U18.3, U18.12
unnamed: U20.8, U20.12
unnamed: U8.10, U21.4
unnamed: U22.3, U23.1
unnamed: U23.8, U23.12
unnamed: U24.3, U25.1
unnamed: U25.3, U29.9 (2Y3)
PC_MASTER_AUD: ACC1.30; also elsewhere on the board
PC_RX_ISOL: TR4.P$3; also elsewhere on the board
PC_TX_ISOL: ACC1.29, TR5.P$3
RETRANSMIT_DBCED: D18.5 (AG), IC1.1 (J), SW5.3 (C), U17.3, U17.9, U18.10, U29.6 (1A2); also elsewhere on the board
RETRANSMIT_NEVER_DBCED: D18.3 (AR), U13.2, U17.5, U17.10, U18.5, U23.2, U29.2 (1A0); also elsewhere on the board
ROGER_AUDIO: SW4.2 (B); also elsewhere on the board
ROGER_AUDIO_SW: SW4.1 (A); also elsewhere on the board
ROGER_PTT_CNTRL_OUT: SW4.4 (A); also elsewhere on the board
SIMPLEX_MASTER_AUD: ACC1.28; also elsewhere on the board
SPX_ENABLE: U20.13; also elsewhere on the board
SPX_RX_ISOL: ACC1.24, K2.12, TR3.P$3
SPX_RX_ISOL_SW: K2.11; also elsewhere on the board
SPX_TX_ISOL: ACC1.27, TR2.P$3
~DPX_LOOP_INHIBIT: U8.4, U22.1

Notes on the sheet:
Switch DPDT: TST 2 N-RA KNITTER-SWITCH; Swtich SPDT: TST 1 D-RA KNITTER-SWITCH; 5FS1S102M6QE NINIGI
GV == SOT753 == TSOP-5_1.65x3.05mm_P0.95mm
PC_FROM_AUD - Audio from PC PC_TO_AUD - Audio to PC PC_TO_RETR_ACTIVE - Signal to PC that retransmission is active PC_FROM_PTT - Signal from PC to control PTT
GW == TSSOP5 == SOT-353_SC-70-5_Handsoldering

Parts:
C6: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C60: 47u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
R48, R49: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U26: NE555D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C7.1, R48.2, U26.4 (R), U26.8 (VCC); also elsewhere on the board
/555Timer/555_CV: C6.1, U26.5 (CV)
/555Timer/555_THR: C60.1, R49.1, U26.2 (TR), U26.6 (THR)
CLK: U26.3 (Q); also elsewhere on the board
GND: C6.2, C7.2, C60.2, U26.1 (GND); also elsewhere on the board
unnamed: R48.1, R49.2, U26.7 (DIS)

Parts:
C49: 67u; CP_Radial_D8.0mm_P3.50mm
C50, C51, C52, C53, C54, C55: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C56, C57: 10u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C58: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D20: MURS120-E3; D_SMB_Handsoldering
F2, F3: Polyfuse; Fuse_2010_5025Metric_Pad1.52x2.65mm_HandSolder
F5: Fuse; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
FL1: NFE31PT222Z1E9L; FIL_NFE31PT222Z1E9L
J9: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
L1: 100n; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U40, U41: L7805; TO-220-3_Horizontal_TabDown

Connections:
+5V: F2.2; also elsewhere on the board
+BATT: D20.2 (A), J9.1
+VDC: C49.1, C50.1, C51.1, FL1.3, U40.1 (IN), U41.1 (IN); also elsewhere on the board
/Power/+5V_UNFUSED: C53.1, C55.1, C57.1, F2.1, U41.3 (OUT)
/Power/VDDA_UNFUSED: C52.1, C54.1, C56.1, L1.1, U40.3 (OUT)
GND: C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, FL1.2, FL1.2_1, FL1.2_2, J9.2, U40.2 (GND), U41.2 (GND); also elsewhere on the board
unnamed: C58.1, F3.1, L1.2
unnamed: D20.1 (K), F5.1
unnamed: F5.2, FL1.1
VDDA: F3.2; also elsewhere on the board

Parts:
C21, C38, C39, C40, C41, C45, C46: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C22, C42, C48: 220u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C23, C24, C27, C28, C29, C30, C31, C32, C37, C47: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25, C26, C33, C34, C35, C36: 22u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C43: 2u2; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C44: 10u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
DPX_HI1: 10k; Potentiometer_SRpassives_1028F
DPX_LO1: 10k; Potentiometer_SRpassives_1028F
DPX_VOL_1: 10k; Potentiometer_SRpassives_1028F
IC4: LM567CH; SOIC-8_3.9x4.9mm_P1.27mm
IC5: 74HC107D; SO-14_3.9x8.65mm_P1.27mm
J3: AudioJack3; Jack_3.5mm_Lumberg_1503_07_Horizontal
MAIN_OUT_VOL_DPX_1: 10k; Potentiometer_Alps_RK163_Single_Horizontal
MAIN_OUT_VOL_PC_1: 10k; Potentiometer_Alps_RK163_Single_Horizontal
MAIN_OUT_VOL_SPX_1: 10k; Potentiometer_Alps_RK163_Single_Horizontal
PC_VOL_1: 10k; Potentiometer_SRpassives_1028F
R69, R74, R84, R85, R86, R87, R88, R89, R94, R95, R100, R104, R118, R121: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R70, R71, R72, R73, R75, R101, R102, R103, R105, R119, R120, R122: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R76, R77, R78, R79, R80, R81, R82, R83: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R90, R91, R92, R93, R96, R97, R98, R99, R106, R107, R108, R109, R110, R111, R112, R113, R116, R117: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R114, R115: 33k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV4: 10k; Potentiometer_Bourns_3314J_Vertical
SPX_HI1: 10k; Potentiometer_SRpassives_1028F
SPX_LO1: 10k; Potentiometer_SRpassives_1028F
SPX_VOL_1: 10k; Potentiometer_SRpassives_1028F
U33, U34, U36, U37, U38: LMV358; SOIC-8_3.9x4.9mm_P1.27mm
U39: 74HC04; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: IC4.4 (V+), IC5.8 (J), IC5.10 (~RST), IC5.11 (K), IC5.14 (VCC), R116.2, U39.14 (VCC); also elsewhere on the board
/AudioFilters/TONE_DET: IC4.8 (OUTPUT), R116.1, U39.5
DPX_RX_ISOL_SW: DPX_VOL_1.1; also elsewhere on the board
DPX_RX_ISOL_SW_VOL: C37.1, DPX_VOL_1.2, R76.1, R80.1
DUPLEX_MASTER_AUD: MAIN_OUT_VOL_DPX_1.2; also elsewhere on the board
DUPLEX_MIX: C45.2, R101.1, R120.1; also elsewhere on the board
DUPLEX_MIX_SW: R71.1; also elsewhere on the board
GND: C29.1, C30.1, C43.1, C44.2, C47.2, DPX_HI1.1, DPX_LO1.3, DPX_VOL_1.3, IC4.7 (GND), IC5.7 (GND), MAIN_OUT_VOL_DPX_1.3, MAIN_OUT_VOL_PC_1.3, MAIN_OUT_VOL_SPX_1.3, PC_VOL_1.3, R74.2, R77.2, R79.2, R81.2, R83.2, R85.2, R87.2, R94.1, R95.1, R104.2, R110.1, R111.1, R121.2, SPX_HI1.1, SPX_LO1.3, SPX_VOL_1.3, U33.4 (V-), U34.4 (V-), U36.4 (V-), U37.4 (V-), U38.4 (V-), U39.7 (GND); also elsewhere on the board
unnamed: C21.1, PC_VOL_1.2
unnamed: C22.1, R75.2, U36.1
unnamed: C22.2, MAIN_OUT_VOL_DPX_1.1
unnamed: C23.1, C27.2, R96.1
unnamed: C23.2, R76.2, R77.1
unnamed: C24.1, C28.2, R97.1
unnamed: C24.2, R78.2, R79.1
unnamed: C25.1, R84.2, R85.1, R90.1
unnamed: C25.2, R80.2, R81.1
unnamed: C26.1, R86.2, R87.1, R92.1
unnamed: C26.2, R82.2, R83.1
unnamed: C27.1, R91.2, U33.5 (+)
unnamed: C28.1, R93.2, U34.5 (+)
unnamed: C29.2, R98.2, U33.3 (+)
unnamed: C30.2, R99.2, U34.3 (+)
unnamed: C31.1, R90.2, R98.1
unnamed: C31.2, C35.1, U33.1, U33.2 (-)
unnamed: C32.1, R92.2, R99.1
unnamed: C32.2, C36.1, U34.1, U34.2 (-)
unnamed: C33.1, R96.2, U33.6 (-), U33.7
unnamed: C33.2, DPX_HI1.3
unnamed: C34.1, R97.2, U34.6 (-), U34.7
unnamed: C34.2, SPX_HI1.3
unnamed: C35.2, DPX_LO1.1
unnamed: C36.2, SPX_LO1.1
unnamed: C37.2, IC4.3 (INPUT)
unnamed: C38.1, DPX_LO1.2
unnamed: C38.2, R106.1
unnamed: C39.1, DPX_HI1.2
unnamed: C39.2, R107.1
unnamed: C40.1, SPX_LO1.2
unnamed: C40.2, R108.1
unnamed: C41.1, SPX_HI1.2
unnamed: C41.2, R109.1
unnamed: C42.1, R105.2, U36.7
unnamed: C42.2, MAIN_OUT_VOL_SPX_1.1
unnamed: C43.2, IC4.2 (LOOPFIL)
unnamed: C44.1, IC4.1 (OUTFILTER)
unnamed: C45.1, R114.2, U37.1
unnamed: C46.1, R115.2, U37.7
unnamed: C47.1, IC4.6 (TIMCAP), R117.2
unnamed: C48.1, R122.2, U38.1
unnamed: C48.2, MAIN_OUT_VOL_PC_1.1
unnamed: IC4.5 (TIMRES), RV4.1
unnamed: IC5.9 (~CLK), U39.6
unnamed: R69.2, R74.1, U36.3 (+)
unnamed: R70.2, R71.2, R72.2, R73.2, R75.1, U36.2 (-)
unnamed: R78.1, R82.1, SPX_VOL_1.2
unnamed: R88.1, R91.1, R94.2
unnamed: R89.1, R93.1, R95.2
unnamed: R100.2, R104.1, U36.5 (+)
unnamed: R101.2, R102.2, R103.2, R105.1, U36.6 (-)
unnamed: R106.2, R107.2, R114.1, U37.2 (-)
unnamed: R108.2, R109.2, R115.1, U37.6 (-)
unnamed: R110.2, R112.1, U37.3 (+)
unnamed: R111.2, R113.1, U37.5 (+)
unnamed: R117.1, RV4.2, RV4.3
unnamed: R118.2, R121.1, U38.3 (+)
unnamed: R119.2, R120.2, R122.1, U38.2 (-)
PC_MASTER_AUD: MAIN_OUT_VOL_PC_1.2; also elsewhere on the board
PC_MIX: C21.2, R72.1, R102.1
PC_RX_ISOL: PC_VOL_1.1; also elsewhere on the board
ROGER_AUDIO_SW: R73.1, R103.1; also elsewhere on the board
SIMPLEX_MASTER_AUD: MAIN_OUT_VOL_SPX_1.2; also elsewhere on the board
SIMPLEX_MIX: C46.2, R70.1, R119.1
SPX_ENABLE: IC5.5 (Q); also elsewhere on the board
SPX_RX_ISOL_SW: SPX_VOL_1.1; also elsewhere on the board
VDDA: R69.1, R84.1, R86.1, R88.2, R89.2, R100.1, R112.2, R113.2, R118.1, U33.8 (V+), U34.8 (V+), U36.8 (V+), U37.8 (V+), U38.8 (V+); also elsewhere on the board

Parts:
C16, C18, C20: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 220u; CP_EIA-7343-31_Kemet-D_Pad2.25x2.55mm_HandSolder
C19: 10u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
D19: 1N4148W; D_SOD-123
Q5, Q6: BC858; SOT-23
Q7: BC848; SOT-23
R57, R60: 5k1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R58, R59: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R61, R64: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R62, R63: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65, R66, R67: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: 100k; Potentiometer_Bourns_3314J_Vertical
RV2: 10k; Potentiometer_Bourns_3314J_Vertical
RV3: 10k; Potentiometer_SRpassives_1028F
U31: HEF4093B; SO-14_3.9x8.65mm_P1.27mm
U32: 74AHC1G32GW; SOT-353_SC-70-5_Handsoldering

Connections:
+5V: C19.1, C20.1, Q5.2 (E), Q6.2 (E), R64.1, U31.14 (VCC), U32.5 (VCC); also elsewhere on the board
GND: C16.2, C17.2, C18.2, C19.2, C20.2, Q7.2 (E), R58.1, R59.2, R65.1, R66.1, RV3.3, U31.7 (GND), U32.3 (GND); also elsewhere on the board
unnamed: C16.1, RV2.3, U31.12
unnamed: C17.1, D19.2 (A), RV1.1, U31.1, U31.2
unnamed: C18.1, R67.2, R68.1
unnamed: D19.1 (K), RV1.2, RV1.3, U31.4, U31.8
unnamed: Q5.1 (B), R57.2
unnamed: Q5.3 (C), R59.1, U31.5
unnamed: Q6.1 (B), R60.1
unnamed: Q7.1 (B), R61.2
unnamed: Q7.3 (C), R60.2, R64.2, U31.13
unnamed: R61.1, U31.6, U31.10
unnamed: R62.1, R66.2, U32.2
unnamed: R63.1, R65.2, U32.1
unnamed: R67.1, RV2.1, RV2.2, U31.11
unnamed: R68.2, RV3.1
unnamed: U31.3, U31.9
RETRANSMIT_DBCED: R62.2; also elsewhere on the board
RETRANSMIT_NEVER_DBCED: R63.2; also elsewhere on the board
ROGER_AUDIO: RV3.2; also elsewhere on the board
ROGER_PTT_CNTRL_OUT: Q6.3 (C), R58.2; also elsewhere on the board
ROGER_PTT_INPUT: R57.1, U32.4

Notes on the sheet:
DURATION
TONE
VOLUME
