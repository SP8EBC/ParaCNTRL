# Repository SP8EBC/ParaCNTRL (continued)

## KiCad design fm-rpt-control.kicad_pcb (continued)

Board: 2 copper layers, 159.3 x 158.8 mm, 314 parts (3 on the bottom side), 286 nets.

## Commit log

2023-02-25 first commit with kicad files
2023-02-26 gitignore
2023-02-26 daily
2023-02-26 second daily
2023-03-08 schematic design ready
2023-03-09 PCB dimenstions set and db/din sockets, pots, switches and leds placed
2023-03-09 controlling to_pc_retransmission line
2023-03-12 logic ics, relays and relay driving electronics, voltage regulators placed
2023-03-13 before replacing some pinheaders with switches
2023-03-13 short
2023-03-13 +5v bus removed completely
2023-03-13 test
2023-03-13 short fixed
2023-03-14 all components placed on pcb
2023-03-15 some traces in logic section
2023-03-28 before moving connector to separate schematic scheets
2023-03-28 moving_connectors_to_separate_sch
2023-03-28 before moving separated connectors to distinct scheet
2023-03-28 pcb synced with schematics
2023-03-28 moved to separate scheed, before reasigning designators
2023-03-28 connector annotated
    pcb updated after manually annotating back connector sheet
    all scheets reanotated in new way
    all scheets reanotated in new way ...
2023-03-31 done
2023-04-03 gerber files, some minor bugs in PCB solved
2023-04-04 bugfix: not negating DPX_TX_TAIL_CLR before feeding 74hc107
2023-04-29 roger beep sligtly redesigned during assembly and debugging, bom with prices
2023-05-01 some minor changes in schematic only after protoype testing
2023-05-04 pullup,pulldown resistors changed
2023-05-05 changes in pcb design rerouted except chanes around roger beep genrator. new hw rev
2023-05-06 roger beep generator pcb design reworked
2023-05-07 footprint of led indicators, rc delay network btween u9 and u12
2023-05-07 reannotated
2023-05-07 lm567 tone detect test results
2023-05-07 simplex enable bugifx, now not inhibiting
2023-05-07 simplex remote control tone detector redesigned, gerber files for hw-rev b
2023-05-08 changing rogereep duration depends on simplex enable or not
2023-05-08 regenerated HW-revB gerbers
2023-06-10 values of few resistors changed according to testing first unit of hw rev b
2023-06-19 some changes after testing hw revision b
2024-03-24 daily???
2024-03-26 before fixing problems with potentiometers orientation
